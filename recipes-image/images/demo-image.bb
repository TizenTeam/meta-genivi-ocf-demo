require recipes-demo-platform/images/genivi-demo-platform.bb 

IMAGE_INSTALL += " iotivitymap "

